# Keil uVision project SIN.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SIN
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c stm32f4xx_it.c ThAltavoz.c Arial12x12.h lcd.c lcd.h ThLCD.c
  group Conf
    ./: tim.c tim.h dma.c dma.h dac.c dac.h rtc.c rtc.h
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Board Support:LED 1.0.0, CMSIS Driver:SPI 2.15, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DAC 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:RTC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:Startup 2.6.3
